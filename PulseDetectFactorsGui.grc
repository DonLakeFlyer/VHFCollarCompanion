<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PulseDetectFactorsGui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_samp_rate</value></param>
<param><key>value</key><value>samp_rate/total_decimation</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>21</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>21</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>minSamplesForPulse</value></param>
<param><key>value</key><value>35</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Min samples for pulse</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>300</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pllFreqMax</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>PLL Freq Max</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>2.5</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_decimation</value></param>
<param><key>value</key><value>16*16*4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wnT</value></param>
<param><key>value</key><value>math.pi/4.0*0+0.635</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>PLL Loop BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>math.pi</value></param>
</block>
<block>
<key>PulseDetectBase</key>
<param><key>id</key><value>PulseDetectBase</value></param>
<param><key>freq_shift</key><value>0</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>pllFreqMax</key><value>pllFreqMax</value></param>
<param><key>wnT</key><value>wnT</value></param>
<param><key>pulse_freq</key><value>pulse_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>VHFPulseDetect_pulse_detect__ff</key>
<param><key>id</key><value>VHFPulseDetect_pulse_detect__ff_0</value></param>
<param><key>minSamplesForPulse</key><value>minSamplesForPulse</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>VHFPulseSender_udp_sender_f</key>
<param><key>id</key><value>VHFPulseSender_udp_sender_f_0</value></param>
<param><key>channel_index</key><value>0</value></param>
<param><key>localhost</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>146e6</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Pulse Detect</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Pulse Raw</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Moving Avg</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Moving Var</value></param>
<param><key>color5</key><value>"magenta"</value></param>
<param><key>label5</key><value>Moving StdDev</value></param>
<param><key>color6</key><value>"cyan"</value></param>
<param><key>label6</key><value>Threshold</value></param>
<param><key>name</key><value>"Pulse Processing Views"</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>size</key><value>int(final_samp_rate*10.0)</value></param>
<param><key>srate</key><value>final_samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>VHFPulseDetect_pulse_detect__ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>VHFPulseSender_udp_sender_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
</flow_graph>
