<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PulseDetectCmdLineBT</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_samp_rate</value></param>
<param><key>value</key><value>samp_rate/total_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_decimation</value></param>
<param><key>value</key><value>4*8*8</value></param>
</block>
<block>
<key>PulseDetectBase</key>
<param><key>id</key><value>PulseDetectBase</value></param>
<param><key>freq_shift</key><value>0</value></param>
<param><key>lna_gain</key><value>11</value></param>
<param><key>mixer_gain</key><value>11</value></param>
<param><key>wnT</key><value>math.pi/4.0*0+0.635</value></param>
<param><key>pulse_freq</key><value>pulse_freq</value></param>
<param><key>vga_gain</key><value>15</value></param>
</block>
<block>
<key>VHFPulseDetect_pulse_detect__ff</key>
<param><key>id</key><value>VHFPulseDetect_pulse_detect__ff_0</value></param>
</block>
<block>
<key>VHFPulseSender_bt_sender_f</key>
<param><key>id</key><value>VHFPulseSender_bt_sender_f_0</value></param>
<param><key>channel_index</key><value>channel_index</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_index</value></param>
<param><key>label</key><value>Channel Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>146e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>VHFPulseDetect_pulse_detect__ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>VHFPulseSender_bt_sender_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>blocks_vector_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
