<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PulseDetectCmdLineBT</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_samp_rate</value></param>
<param><key>value</key><value>samp_rate/total_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_decimation</value></param>
<param><key>value</key><value>4*8*8</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>GRCPulseSenderBT</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
import bluetooth
from gnuradio import gr

class blk(gr.sync_block):
    def __init__(self, factor=1.0):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.factor = factor
        self.serverSocket = None


    def work(self, input_items, output_items):
        if not self.serverSocket:
                # Setup bluetooth socket
                self.serverSocket = bluetooth.BluetoothSocket (bluetooth.RFCOMM)
                self.serverSocket.bind(("", 0x1001))
                self.serverSocket.listen(1)

                # Advertise service
                uuid = "94f39d29-7d6d-437d-973b-fba39e49d4ee"
                bluetooth.advertise_service(
				self.serverSocket,
				"PulseServer",
				service_id = uuid,
				service_classes = [ uuid, SERIAL_PORT_CLASS ],
				profiles = [ SERIAL_PORT_PROFILE ])
                #logging.debug("Waiting for bluetooth connection")
                #self.clientSocket, clientInfo = self.serverSocket.accept()
                #print("Accepted connection from ", clientInfo)
                #self.clientSocket.setblocking(False)

        print "length of input vector =",  len(input_items[0])
        print "length of output vector =",  len(output_items[0])
        output_items[0][:] = input_items[0]
        return len(output_items[0])
</value></param>
<param><key>factor</key><value>1.0</value></param>
</block>
<block>
<key>PulseDetectBase</key>
<param><key>id</key><value>PulseDetectBase</value></param>
<param><key>freq_shift</key><value>0</value></param>
<param><key>lna_gain</key><value>11</value></param>
<param><key>mixer_gain</key><value>11</value></param>
<param><key>wnT</key><value>math.pi/4.0*0+0.635</value></param>
<param><key>pulse_freq</key><value>pulse_freq</value></param>
<param><key>vga_gain</key><value>15</value></param>
</block>
<block>
<key>VHFPulseDetect_pulse_detect__ff</key>
<param><key>id</key><value>VHFPulseDetect_pulse_detect__ff_0</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>146e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<connection><source_block_id>GRCPulseSenderBT</source_block_id><sink_block_id>blocks_vector_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>VHFPulseDetect_pulse_detect__ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>VHFPulseDetect_pulse_detect__ff_0</source_block_id><sink_block_id>GRCPulseSenderBT</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
