<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PulseDetectBase</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate_1</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate_2</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate_3</value></param>
<param><key>value</key><value>final_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fmax</value></param>
<param><key>value</key><value>pllFreqMax</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fmin</value></param>
<param><key>value</key><value>-pllFreqMax</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>inter_pulse_duration</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate2</value></param>
<param><key>value</key><value>samp_rate/decimate_1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate3</value></param>
<param><key>value</key><value>samp_rate2/decimate_2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate4</value></param>
<param><key>value</key><value>samp_rate3/decimate_3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps1</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate, 1.5e3, 128e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps1_len</value></param>
<param><key>value</key><value>len(taps1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps2</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate2, 1.5e3, 16e3-1.5e3, 60.0, firdes.WIN_BLACKMAN_HARRIS, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps2_len</value></param>
<param><key>value</key><value>len(taps2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps3</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate3, 1.5e3, 0.3e3, 30.0, firdes.WIN_KAISER, 6.76/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps3_len</value></param>
<param><key>value</key><value>len(taps3)</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>wnT</value></param>
<param><key>max_freq</key><value>math.pi/(samp_rate4/2.0)*fmax</value></param>
<param><key>min_freq</key><value>math.pi/(samp_rate4/2.0)*fmin</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>avg_pulse</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Average Pulse Output</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/parallels/repos/VHFCollarCompanion/far.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>int(samp_rate4*pulse_duration)</value></param>
<param><key>max_iter</key><value>int(samp_rate4*inter_pulse_duration/10.0)</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>final_decimation</value></param>
<param><key>label</key><value>Final decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>decimate_2</value></param>
<param><key>taps</key><value>taps2</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>decim</key><value>decimate_3</value></param>
<param><key>taps</key><value>taps3</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decimate_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>pulse_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>airspy=0,sensitivity</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pllFreqMax</value></param>
<param><key>label</key><value>PLL Freq Max</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_duration</value></param>
<param><key>label</key><value>Pulse duration (secs)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.015</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pulse_freq</value></param>
<param><key>label</key><value>Pulse Freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>146000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>Decimated Spectrum</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wnT</value></param>
<param><key>label</key><value>PLL Loop BW</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>math.pi/4.0*0+0.635</value></param>
</block>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>avg_pulse</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
