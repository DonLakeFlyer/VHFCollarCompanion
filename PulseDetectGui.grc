<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PulseDetectGUI</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_samp_rate</value></param>
<param><key>value</key><value>samp_rate/total_decimation</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_shift</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Frequency Shift</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-500e3</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>500e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lna_gain</value></param>
<param><key>value</key><value>11</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>14</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mixer_gain</value></param>
<param><key>value</key><value>11</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Mixer Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_freq</value></param>
<param><key>value</key><value>146e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_decimation</value></param>
<param><key>value</key><value>4*8*8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>VGA Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wnT</value></param>
<param><key>value</key><value>math.pi/4.0*0+0.635</value></param>
<param><key>gui_hint</key><value>8,0,1,1</value></param>
<param><key>label</key><value>PLL Loop BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>math.pi</value></param>
</block>
<block>
<key>PulseDetectBase</key>
<param><key>id</key><value>PulseDetectBase</value></param>
<param><key>freq_shift</key><value>freq_shift</value></param>
<param><key>lna_gain</key><value>lna_gain</value></param>
<param><key>mixer_gain</key><value>mixer_gain</value></param>
<param><key>wnT</key><value>wnT</value></param>
<param><key>pulse_freq</key><value>pulse_freq</value></param>
<param><key>vga_gain</key><value>vga_gain</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>final_samp_rate</value></param>
<param><key>fc</key><value>pulse_freq</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Spectrum</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-65.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>9,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Raw</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Pulse Indicator"</value></param>
<param><key>update_time</key><value>0.005</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Pulse</value></param>
<param><key>name</key><value>"Pulse Processing Views"</value></param>
<param><key>size</key><value>int(final_samp_rate*10.0)</value></param>
<param><key>srate</key><value>final_samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PulseDetectBase</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
